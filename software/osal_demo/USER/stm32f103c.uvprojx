# Keil uVision project stm32f103c.uvprojx, settings and files
target STM32F103Cx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c +hex
  AfterMake: .\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\SOFTWARE\led;..\SOFTWARE\elog;..\SOFTWARE\eeprom;..\SOFTWARE\rtc;..\SOFTWARE\dwt_timer;..\OSAL\osal;..\OSAL\hal;..\OSAL\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../OSAL/app/: osal_main.c print_task.c statistics_task.c
  group OSAL
    ../OSAL/hal/: timer.c
    ../OSAL/osal/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
  group SOFTWARE
    ../SOFTWARE/led/: led.c
    ../SOFTWARE/rtc/: rtc.c
    ../SOFTWARE/eeprom/: soft_i2c.c eeprom.c eeprom_data.c
    ../SOFTWARE/elog/: elog.c elog_utils.c elog_port.c
    ../SOFTWARE/dwt_timer/: dwt_timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
